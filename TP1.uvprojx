# Keil uVision project TP1.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: TP1
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: RK_Config_Moteur.s RK_PriseEnMain_Moteurs.s
software components: CMSIS:CORE 5.6.0, Device:Startup 1.2.2
